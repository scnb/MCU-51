# Keil uVision project adc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: adc
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE
  group Source Group 1
    ./: STARTUP.A51 main.c
  group HARDWARE
    ./HARDWARE/: 1602.c i2c_pcf8591.c
