# Keil uVision project i2c_uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: i2c_uart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: i2c_uart.c
    ./: 1602.c
