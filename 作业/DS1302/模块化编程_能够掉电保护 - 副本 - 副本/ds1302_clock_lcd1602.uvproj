# Keil uVision project ds1302_clock_lcd1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ds1302_clock_lcd1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: ds1302.c i2c_eeprom.c lcd1602.c main.c hc595.c
