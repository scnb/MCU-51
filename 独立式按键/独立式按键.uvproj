# Keil uVision project 独立式按键.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 独立式按键 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: delay.c hc595.c Independent_Button.c
